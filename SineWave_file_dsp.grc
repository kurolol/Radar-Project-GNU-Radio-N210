options:
  parameters:
    generate_options: qt_gui
    id: FMCW
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '70'
  states: {}
- name: ds_samp_rate
  id: variable
  parameters:
    value: 200e3 / decimation
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\juani\Desktop\VM Share\alexiscar4mph200k.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '512'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '60'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, fft_size=512, samp_rate=3636):
              gr.sync_block.__init__(
                  self,
                  name="FFT, Peaks, and Velocity",
                  in_sig=[(np.complex64, int(fft_size))], 
                  out_sig=[np.float32, np.float32] 
              )
              self.fft_size = int(fft_size)
              self.samp_rate = float(samp_rate)

          def work(self, input_items, output_items):
              in_vectors   = input_items[0]      
              out_mph      = output_items[0]     
              out_m_s      = output_items[1]     

              N  = self.fft_size
              fs = self.samp_rate
              
              for i, time_vector in enumerate(in_vectors):
                  # 1) Compute FFT
                  freq_vector = np.fft.fft(time_vector)

                  # 2) Shift so DC is in the middle bin
                  freq_vector = np.fft.fftshift(freq_vector)

                  # 3) Power spectrum
                  power_spectrum = np.abs(freq_vector)

                  # 4) Find strongest bin
                  max_bin = np.argmax(power_spectrum)

                  # 5) Convert bin index to frequency offset in Hz
                  bin_offset = (max_bin - N/2)   # with Shift=Yes, center = N/2
                  freq_offset_hz = bin_offset * (fs / N)

                  # 6) Compute speed in mph & m/s
                  speed_mph = freq_offset_hz * 0.14
                  speed_ms  = freq_offset_hz * 0.0625

                  # 7) Write to outputs
                  out_mph[i] = speed_mph
                  out_m_s[i] = speed_ms
              
              return len(out_mph)
    fft_size: '512'
    samp_rate: ds_samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200'
    decim: '1'
    gain: '1'
    samp_rate: ds_samp_rate
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Make sure Samp_rate matches the dat file's sample rate
  states: {}
- name: note_1
  id: note
  parameters:
    note: Make sure ds_samp_rate matches the new downsampled sample rate (samp_rate / decimation)
  states: {}
- name: note_2
  id: note
  parameters:
    note: if signal is week and not near 0 peak try enabling this
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '15'
    min: '-15'
    name: '"MPH"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '15'
    min: '-15'
    name: '"m/s"'
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: ds_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Downsampled + LPF"'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: ds_samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    type: ccc
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_1, '0']
- [blocks_throttle2_0, '0', rational_resampler_xxx_0, '0']
- [dc_blocker_xx_0, '0', blocks_stream_to_vector_0, '0']
- [dc_blocker_xx_0, '0', qtgui_sink_x_0, '0']
- [epy_block_1, '0', qtgui_number_sink_1, '0']
- [epy_block_1, '1', qtgui_number_sink_1_0, '0']
- [low_pass_filter_0, '0', blocks_stream_to_vector_0, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
